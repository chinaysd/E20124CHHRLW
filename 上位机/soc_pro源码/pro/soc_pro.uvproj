# Keil uVision project soc_pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC93F8333 SC93Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x3FF) CLOCK(24000000)
  output: soc_pro +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\app;..\bsp;..\lib;..\lib\inc
  group startup
    ./: STARTUP.A51
  group bsp
    ../bsp/: bsp_pwm.c bsp_uart.c bsp_timer.c TimeOut.c bsp_i2c_s.c bsp_i2c_port.c
  group pro
    ./: main.c
  group app
    ../app/: app.c
  group lib
    ../lib/: S_TouchKeyCFG.C SC93F8XXX_HighSensitive_Lib_T1_V0.0.2.LIB
